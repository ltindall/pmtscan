options:
  parameters:
    generate_options: no_gui
    id: pmtscan
    output_language: cpp
    realtime_scheduling: '1'
    title: pmtscan
  states: {}

blocks:
- name: freq_end
  id: variable
  parameters:
    value: 6e9
  states: {}
- name: freq_start
  id: variable
  parameters:
    value: 70e6
  states: {}
- name: points
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8.192e6
  states: {}
- name: tune_step_fft
  id: variable
  parameters:
    value: '32'
  states: {}
- name: tune_step_hz
  id: variable
  parameters:
    value: int(samp_rate / 2)
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: points
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: test.tsv
    type: byte
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: points
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: points
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(points)
  states: {}
- name: habets39_sweepsinkv_0
  id: habets39_sweepsinkv
  parameters:
    freq_end: freq_end
    freq_start: freq_start
    samp_rate: samp_rate
    tag: rx_freq
    tune_step_fft: tune_step_fft
    tune_step_hz: tune_step_hz
    vlen: points
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 70e6
    dev_addr: type=b200
    dev_args: num_recv_frames=1000,recv_frame_size=16360
    gain0: '40'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', habets39_sweepsinkv_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_0, '0']
- [habets39_sweepsinkv_0, '0', blocks_file_sink_0, '0']
- [habets39_sweepsinkv_0, tune, uhd_usrp_source_0, command]
- [uhd_usrp_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
